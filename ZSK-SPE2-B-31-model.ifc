Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:38+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-SPE2-B-31
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-SPE2-B-31 Скамья «Арка 100» · база — серый бетон
In: Площадка
Description: Изделие бетонное благоустройства. Скамья «Арка 100» · база — серый бетон; Classification: 59.1.15.01-1076 Скамья (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-SPE2-B-31; ModelReference: Скамья «Арка 100» · база — серый бетон; ProductionYear: 2026; ArticleNumber: ZSK-SPE2-B-31
ORION_Изделие - Артикул: ZSK-SPE2-B-31; Артикул прежний: SD-SPE2-B-31; Наименование: Скамья «Арка 100» · база — серый бетон; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 1000×450×450 мм; Материал: Бетон; Цена: 40 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20916; Код КСИ: CPr>EDD070; Класс КСИ: Скамья; Коды КСР: 59.1.15.01-1076 … 59.1.15.02-0539
ADSK - ADSK_Наименование: Скамья «Арка 100» · база — серый бетон; ADSK_Марка: ZSK-SPE2-B-31; ADSK_Код изделия: 59.1.15.01-1076; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20916
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDD070; ZSK_Артикул_прежний: SD-SPE2-B-31
Qto_ORION - Длина: 1000 mm; Ширина: 450 mm; Высота: 450 mm
